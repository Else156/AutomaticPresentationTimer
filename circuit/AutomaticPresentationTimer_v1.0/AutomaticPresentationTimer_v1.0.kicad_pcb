# Repository Else156/AutomaticPresentationTimer

File README.md:

# 物理ベル式 プレゼンテーションタイマー 

Raspberry Pi Pico、SSD1306 OLEDディスプレイ、ソレノイド、およびチンベルを使用したプレゼンテーションタイマーです。
設定した時間（例：予鈴、中間鈴、終了鈴）になると、物理的なベルを「チン！」と鳴らして知らせます。
操作にはRGBロータリーエンコーダを使用し、直感的なメニュー操作と時間設定が可能です。

## ✨ 特徴

* **物理ベル鳴動**: ソレノイドを使用し、設定時間にチンベルを鳴らします。
* **3段階のアラーム設定**: 1回目（1回鳴る）、2回目（2回鳴る）、終了時（3回鳴る）の時間を個別に設定可能。
* **直感的なUI**: ロータリーエンコーダを回して選択・数値変更、押し込んで決定。
* **設定保存機能**: 設定した時間は内蔵フラッシュに保存され、電源を切っても保持されます。
* **加速スクロール**: 時間設定時、エンコーダを速く回すと数値が大きく変化する加速処理を搭載。
* **OLEDディスプレイ**: 現在の残り時間、設定状態、操作ガイドを分かりやすく表示。

## 🛠 ハードウェア構成

### 使用部品

| 部品名 | 型番 | URL | 備考 |
| :--- | :--- | :--- | :--- |
| Raspberry Pi Pico | SC0915 | [購入先URL](https://akizukidenshi.com/catalog/g/g116132/) | |
| 有機ELディスプレイ(OLED) 白色 |  | [購入先URL](https://akizukidenshi.com/catalog/g/g112031/)| |
| イルミネーションロータリーエンコーダ用ピッチ変換基板 | SFE-BOB-11722 | [購入先URL](https://www.switch-science.com/products/1308?srsltid=AfmBOopGGrrqZFvyvS5xYhzGZG8HVmHDNQKUY4yKhhwYDoHrCVhfIAhd) | 廃盤だが千石電商では販売(2026年1月時点） |
| ソレノイド | ZHO-0420S-05A4.5(5V) | [購入先URL](https://akizukidenshi.com/catalog/g/g110761//) | |
| NchパワーMOSFET | 2SK4017(Q) | [購入先URL](https://akizukidenshi.com/catalog/g/g107597/) | |
| カーボン抵抗　10kΩ | RD25S 10K | [購入先URL](https://akizukidenshi.com/catalog/g/g125103/) | |
| 汎用整流用ダイオード 1000V1A | 1N4007-B | [購入先URL](https://akizukidenshi.com/catalog/g/g108327/) | |
| 電解コンデンサー1000μF35V | 35ZLH1000MEFC12.5X20 | [購入先URL](https://akizukidenshi.com/catalog/g/g102722/) | |
| チェック端子(テストポイント) | TEST-22 | [購入先URL](https://akizukidenshi.com/catalog/g/g112216/) | |
| チンベル（卓上ベル） |  |  | |

### 🔌 配線 (Pinout)

`hardware.py` のデフォルト設定に基づく配線図です。

| 部品 | ピン名 | Pico GPIO | 備考 |
| :--- | :--- | :--- | :--- |
| **OLED (I2C)** | SDA | GP0 | |
| | SCL | GP1 | |
| | VCC/GND | - | 3.3V / GND |
| **Encoder** | A相 (CLK) | GP10 | Pull-Up設定 |
| | B相 (DT) | GP11 | Pull-Up設定 |
| | Switch (SW)| GP12 | Pull-Up設定 (Active Low) |
| | GND | - | 共通GND |
| **Solenoid** | Gate/Base | GP15 | **要ドライバ回路** |

> [!WARNING]
> **警告**: ソレノイドをGPIOピン(GP15)に直接接続しないでください。過電流と逆起電力によりPicoが破損します。必ずMOSFET等を使用したドライバ回路と、保護用ダイオードを組み込んでください。

## 📂 ファイル構成

プロジェクトは機能ごとにモジュール化されています。

```text
.
├── circuit/                               # 回路設計関連
│   ├── AutomaticPresentationTimer_v1.0    # Kicadデータが格納
|   └── library/KiCad-RP-Pico-main         # Kicadでの使用ライブラリが格納
├── src/                       # ソースコード
│   ├── main.py                # エントリーポイント。状態遷移と設定の保存/読込を管理
│   ├── hardware.py            # GPIO制御（ソレノイド、エンコーダ、ボタン）
│   ├── display.py             # SSD1306への描画処理
│   ├── presentation_timer_mode.py # タイマー計測・実行モードのロジック
│   ├── setting_mode.py        # メニュー選択モードのロジック
│   ├── edit_mode.py           # 時間設定変更モードのロジック
|   └── settings.json          # 設定保存ファイル (初回実行時に自動生成)
└── README.md
```

> [!WARNING]
> **警告**: プログラムを実行する場合は、ディスプレイ用ドライバライブラリとしてssd1306.pyを得る必要があります。

## KiCad design circuit/AutomaticPresentationTimer_v1.0/AutomaticPresentationTimer_v1.0.kicad_pcb

Parts:
C1: 1000µF 35V; CP_Radial_D10.0mm_P5.00mm
D1: D; D_DO-41_SOD81_P10.16mm_Horizontal
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3
J1: Conn_01x05; PinSocket_1x05_P2.54mm_Vertical
J2: Conn_01x03; PinSocket_1x03_P2.54mm_Vertical
J3: ZHO-0420S-05A4.5(5V); JST_PH_B2B-PH-K_1x02_P2.00mm_Vertical
J4: ディスプレイモジュール; PinSocket_1x04_P2.54mm_Vertical
Q1: 2SK4017; TO-251-3_Vertical
R1: 10k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
TP1: 5V; TestPoint_THTPad_D2.0mm_Drill1.0mm
TP2: 3.3V; TestPoint_THTPad_D2.0mm_Drill1.0mm
TP3: GND; TestPoint_THTPad_D2.0mm_Drill1.0mm
TP4: SDA; TestPoint_THTPad_D2.0mm_Drill1.0mm
TP5: SCL; TestPoint_THTPad_D2.0mm_Drill1.0mm
TP6: GATE; TestPoint_THTPad_D2.0mm_Drill1.0mm
U1: Pico; RPi_Pico_SMD_TH

Connections:
+3.3V: J1.5, J4.2, TP2.1, U1.36 (3V3)
+5V: C1.1, D1.1 (K), J3.1, TP1.1, U1.40 (VBUS)
A(GP10): J2.3, U1.14 (GPIO10)
B(GP11): J2.1, U1.15 (GPIO11)
GND: C1.2, J2.2, J4.1, Q1.3 (S), R1.2, TP3.1, U1.28 (GND)
GP15: Q1.1 (G), R1.1, TP6.1, U1.20 (GPIO15)
unnamed: D1.2 (A), J3.2, Q1.2 (D)
SCL: J4.3, TP5.1, U1.2 (GPIO1)
SDA: J4.4, TP4.1, U1.1 (GPIO0)
SW(GP12): J1.3, U1.16 (GPIO12)

Notes on the sheet:
プッシュスイッチ付きロータリーエンコーダ
ソレノイド動作回路

Board: 2 copper layers, 85.1 x 74.9 mm, 19 parts (1 on the bottom side), 10 nets.

## Commit log

2024-09-24 イメージ図を作成
2024-09-27 vscodeでArudinoを使えるように変更
2024-10-01 vscodeでarduino環境作り途中
2024-10-01 タイマーとディスプレイの大きさを合わせた
2024-10-08 10月5日作業分
2024-10-08 タイマー部分の作成
2024-10-08 環境作成
2024-10-08 デバック用出力を追加
2024-11-12 プログラム加筆
2024-11-12 イメージ図にHDMIポート追加
2024-11-12 ソレノイド追加
2024-11-12 タイマー機能動作確認済み
2024-11-13 参考文献の追加
2024-11-13 11月13日作業分
2025-04-14 プログラム変更
2025-08-18 ディレクトリ構成変更
2025-08-18 プログラム修正
2025-08-19 TODOリストのURLを追記
2025-11-30 ラズパイピコでソレノイドを動かせるようにした
2025-12-07 待機時間の変更
2026-01-18 不要なファイル削除
2026-01-18 概要更新
2026-01-30 ソースコードの立ち位置を記述
2026-01-30 タイマー機能を実装
2026-01-30 不要なインポート文を削除
2026-01-30 状態名変更
2026-01-30 1月31日作業分
2026-02-03 2月4日作業分
2026-02-10 ディレクトリの名前変更
2026-02-10 不要なデータを削除
2026-02-10 コンデンサの名称を修正
2026-02-13 Initialize README with project details and setup
    Added detailed project description, features, hardware configuration, and file structure.
2026-02-13 Update component URLs to include purchase links
2026-02-13 Fix URL formatting in README.md
2026-02-13 Update README to include circuit design and source code
2026-02-13 Update README with warning for display driver
    Added warning about required display driver library.
